options:
  parameters:
    author: root
    generate_options: no_gui
    id: LoRaOTALoopback
    output_language: python
    title: LoRa OTA Loopback
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '2000'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import time\nimport tkinter as tk\nfrom tkinter import simpledialog\nfrom gnuradio import gr\nimport pmt\n\nclass message_prompt(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name=\"message_prompt\",\n            in_sig=None,\n            out_sig=None,\n        )\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.root = tk.Tk()\n        self.root.withdraw()  # Hide the main Tkinter window\n        self.schedule_next_prompt()\n\n    def schedule_next_prompt(self):\n        self.root.after(0, self.prompt_for_message)\n\n    def prompt_for_message(self):\n        payload = simpledialog.askstring(\"Input\", \"Enter payload:\")\n        if payload is not None:\n            message = pmt.intern(payload)\n            for _ in range(3):\n                self.message_port_pub(pmt.intern(\"out\"), message)\n                time.sleep(2)\n        self.schedule_next_prompt()\n\n    def work(self, input_items, output_items):\n        return len(output_items)\n\n"
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "import os\nfrom gnuradio import gr\nimport pmt\n\nclass payload_writer(gr.sync_block):\n    def __init__(self, filepath=\"/home/ubuntu/Documents/Summer-Research-Flowgraphs/message_storage.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"payload_writer\",\n            in_sig=None,\n            out_sig=None,\n        )\n        self.message_port_register_in(pmt.intern(\"payload\"))\n        self.set_msg_handler(pmt.intern(\"payload\"), self.handle_msg)\n        self.filepath = filepath\n        \n        # Overwrite the file every time the flowgraph is run\n        with open(self.filepath, 'w') as file:\n            file.write(\"\")\n\n    def handle_msg(self, msg):\n        if pmt.is_pair(msg):\n            payload = pmt.symbol_to_string(pmt.cdr(msg))\n        else:\n            payload = pmt.symbol_to_string(msg)\n        \n        with open(self.filepath, 'a') as file:\n            file.write(payload + \"\\n\")\n\n    def work(self, input_items, output_items):\n        return len(output_items)\n\n"
    filepath: '"/home/ubuntu/Documents/Summer-Research-Flowgraphs/message_storage.txt"'
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: '1000000'
    sf: '7'
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_0, strobe, lora_tx_0, in]
- [epy_block_0, out, lora_tx_0, in]
- [lora_rx_0, out, blocks_message_debug_0, print]
- [lora_rx_0, out, epy_block_0_0, payload]
- [lora_tx_0, '0', soapy_limesdr_sink_0, '0']
- [soapy_limesdr_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
