options:
  parameters:
    author: ubuntu
    generate_options: no_gui
    id: LoRa_tx_test_flowgraph
    output_language: python
    title: LoRa_tx_test_flowgraph
  states: {}

blocks:
- name: bw
  id: variable_config
  parameters:
    config_file: /home/ubuntu/LoRa_Tests/LoRa_config.ini
    option: bw
    section: LoRa
    type: int
    value: '62500'
    writeback: None
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sf
  id: variable_config
  parameters:
    config_file: /home/ubuntu/LoRa_Tests/LoRa_config.ini
    option: sf
    section: LoRa
    type: int
    value: '7'
    writeback: None
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import time\nimport tkinter as tk\nfrom tkinter import simpledialog\nfrom gnuradio import gr\nimport pmt\n\nclass FileLineTransmitter(gr.sync_block):\n    def __init__(self, file_path = \"/home/ubuntu/Desktop/LoRa BER Testing/tx_test_data\", sf=7, bw=62.5, cr=5):\n        gr.sync_block.__init__(\n            self,\n            name=\"FileLineTransmitter\",\n            in_sig=None,\n            out_sig=None,\n        )\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n        # Open the file and read lines\n        self.lines = self.load_file(file_path)\n        self.current_index = 0\n        self.transmit_delay = 1.5  # seconds\n        self.sf = sf\n        self.bw = bw\n        self.cr = cr\n\n    def load_file(self, file_path):\n        try:\n            with open(file_path, 'r') as file:\n                return file.readlines()\n        except Exception as e:\n            print(f\"Error reading file: {e}\")\n            return []\n\n    def work(self, input_items, output_items):\n        if self.current_index < len(self.lines):\n            # Prepare the message to send\n            print(\"Transmitting line at: \" + str(self.sf) + str(self.bw) + str(self.cr))\n            line = self.lines[self.current_index].strip()\n            message = pmt.intern(line)\n            \n            # Send the message\n            self.message_port_pub(pmt.intern(\"out\"), message)\n            self.current_index += 1\n            \n            # Sleep for the specified delay\n            time.sleep(self.transmit_delay)\n        else:\n            print(\"file done transmitting\")\n\n        # Indicate that we have finished processing\n        return len(output_items)\n\n"
    bw: bw
    cr: '5'
    file_path: '"/home/ubuntu/Desktop/LoRa BER Testing/tx_test_data.txt"'
    sf: sf
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class custom_message_to_bits(gr.basic_block):
          def __init__(self, preamble=[0xAB, 0xCD, 0xEF], file_path="msg.txt"):
              gr.basic_block.__init__(self,
                  name="custom_message_to_bits",
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.preamble = np.array(preamble, dtype=np.uint8)
              self.file_path = file_path
              self.chunk_size = 255
              self.set_output_multiple(8 * (len(self.preamble) + self.chunk_size + 1 + 1))  # Output in bits, including CRC
              self.chunks = []
              self.current_chunk_index = 0
              self.message_port_register_in(pmt.intern("crc_status"))
              self.set_msg_handler(pmt.intern("crc_status"), self.handle_crc_status)
              self.message_port_register_out(pmt.intern("out"))
              self.update_message()
              self.transmission_complete = False  # Flag to indicate transmission complete
              self.send_initial_chunk()  # Send the first chunk immediately

          def update_message(self):
              try:
                  with open(self.file_path, "r") as file:
                      message = file.read().strip()
                  message_bytes = np.frombuffer(message.encode('utf-8'), dtype=np.uint8)
                  self.chunks = [self.add_crc(message_bytes[i:i + self.chunk_size]) for i in range(0, len(message_bytes), self.chunk_size)]
              except FileNotFoundError:
                  print("Message file not found. Using default message.")
                  default_message = "Default Message"
                  message_bytes = np.frombuffer(default_message.encode('utf-8'), dtype=np.uint8)
                  self.chunks = [self.add_crc(message_bytes)]

          def add_crc(self, chunk):
              crc = 0
              for byte in chunk:
                  crc ^= byte
                  for _ in range(8):
                      if crc & 0x80:
                          crc = (crc << 1) ^ 0x07  # Generator polynomial
                      else:
                          crc <<= 1
                  crc &= 0xFF
              crc_bytes = np.array([crc], dtype=np.uint8)
              return np.concatenate((chunk, crc_bytes))

          def send_initial_chunk(self):
              if self.current_chunk_index < len(self.chunks):
                  chunk_data = pmt.init_u8vector(len(self.chunks[self.current_chunk_index]), self.chunks[self.current_chunk_index])
                  chunk_ready_msg = pmt.cons(pmt.intern("chunk_ready"), chunk_data)
                  self.message_port_pub(pmt.intern("out"), chunk_ready_msg)
                  #print(f"Sent initial chunk {self.current_chunk_index}.")

          def general_work(self, input_items, output_items):
              if self.transmission_complete:
                  return -1  # Stop the block and flowgraph

              output = output_items[0]

              if self.current_chunk_index < len(self.chunks):
                  chunk = self.chunks[self.current_chunk_index]
                  payload_length = len(chunk) - 1  # Exclude CRC length from payload length
                  header = np.array([payload_length], dtype=np.uint8)
                  packet = np.concatenate((self.preamble, header, chunk))
                  packet_bits = self.byte_to_bits(packet)

                  output[:len(packet_bits)] = packet_bits
                  produced = len(packet_bits)
              else:
                  print("File transmission complete.")
                  self.transmission_complete = True
                  return -1  # Signal to GNU Radio to stop the flowgraph

              self.consume_each(0)  # No input to consume
              return produced

          def byte_to_bits(self, byte_array):
              """Converts a byte array to a bit array."""
              return np.unpackbits(byte_array)

          def handle_crc_status(self, msg):
              if self.transmission_complete:
                  return  # Do nothing if transmission is complete

              status = pmt.symbol_to_string(pmt.car(msg))

              if status == "crc_pass":
                  if self.current_chunk_index < len(self.chunks) - 1:
                      self.current_chunk_index += 1
                      print(f"CRC passed for chunk {self.current_chunk_index}. Moving to the next chunk.")
                      
                      # Send the "chunk_ready" message along with the chunk data
                      chunk_data = pmt.init_u8vector(len(self.chunks[self.current_chunk_index]), self.chunks[self.current_chunk_index])
                      chunk_ready_msg = pmt.cons(pmt.intern("chunk_ready"), chunk_data)
                      self.message_port_pub(pmt.intern("out"), chunk_ready_msg)
                      
                  else:
                      print("File transmission complete.")
                      self.transmission_complete = True

              elif status == "crc_fail":
                  print(f"Resending chunk {self.current_chunk_index} due to CRC failure.")
    file_path: '''/home/ben/Documents/test2'''
    preamble: '[0xAB, 0xCD, 0xEF, 0xA1, 0x54, 0xEB, 0xBA, 0xDC, 0xFF]'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: bw
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: '1000000'
    sf: sf
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq
    gain: '30.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [epy_block_0, out, blocks_message_debug_0, print]
- [epy_block_0, out, lora_tx_0, in]
- [lora_tx_0, '0', soapy_limesdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
