options:
  parameters:
    author: ben
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fdev
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10*fdev
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/ben/Documents/test3
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self, samp_rate=1e6, fsk_deviation=500e3):\n        gr.sync_block.__init__(\n            self,\n            name='FSK Modulation',\n            in_sig=[np.uint8],\n            out_sig=[np.complex64]\n        )\n        self.samp_rate = samp_rate\n        self.fsk_deviation = fsk_deviation\n        self.center_freq = 0\n        self.phase_inc0 = 2.0 * np.pi * (self.center_freq - self.fsk_deviation) / self.samp_rate\n        self.phase_inc1 = 2.0 * np.pi * (self.center_freq + self.fsk_deviation) / self.samp_rate\n        self.phase = 0\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        in0 = input_items[0]\n\n        # Process the input data\n        if len(in0) > 0:  # Ensure there's input data to process\n            for i in range(len(in0)):\n                if in0[i] == 0:\n                    self.phase += self.phase_inc0\n                else:\n                    self.phase += self.phase_inc1\n                out[i] = np.exp(1j * self.phase)\n                if self.phase > 2.0 * np.pi:\n                    self.phase -= 2.0 * np.pi\n        else:\n            print(\"Received empty input data\")  # Debug: indicate when input data is empty\n\n        return len(out)\n\n"
    fsk_deviation: fdev
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.001'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_file_source_1, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
