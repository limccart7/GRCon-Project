options:
  parameters:
    author: ubuntu
    generate_options: no_gui
    id: LoRa_Loopback
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable_config
  parameters:
    config_file: /home/ubuntu/LoRa_Tests/LoRa_config.ini
    option: bw
    section: LoRa
    type: int
    value: '62500'
    writeback: None
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sf
  id: variable_config
  parameters:
    config_file: /home/ubuntu/LoRa_Tests/LoRa_config.ini
    option: sf
    section: LoRa
    type: int
    value: '7'
    writeback: None
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ubuntu/Desktop/Summer-Research-Flowgraphs/LoRa BER Testing/random_hex_file.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '255'
    type: byte
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "import os\nfrom gnuradio import gr\nimport pmt\n\nclass payload_writer(gr.sync_block):\n    def __init__(self, filepath=\"/home/ubuntu/Desktop/Summer-Research-Flowgraphs/message_storage.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"payload_writer\",\n            in_sig=None,\n            out_sig=None,\n        )\n        self.message_port_register_in(pmt.intern(\"payload\"))\n        self.set_msg_handler(pmt.intern(\"payload\"), self.handle_msg)\n        self.filepath = filepath\n        \n        # Overwrite the file every time the flowgraph is run\n        with open(self.filepath, 'w') as file:\n            file.write(\"\")\n\n    def handle_msg(self, msg):\n        if pmt.is_pair(msg):\n            payload = pmt.symbol_to_string(pmt.cdr(msg))\n        else:\n            payload = pmt.symbol_to_string(msg)\n        \n        with open(self.filepath, 'a') as file:\n            file.write(payload + \"\\n\")\n\n    def work(self, input_items, output_items):\n        return len(output_items)\n\n"
    filepath: '"/home/ubuntu/Desktop/Summer-Research-Flowgraphs/message_storage.txt"'
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '0'
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    minoutbuf: '10000000'
    preamb_len: '8'
    samp_rate: samp_rate
    sf: sf
    sync_words: '[8,16]'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: file_source
    use_length_tag: 'False'
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', lora_sdr_whitening_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', lora_sdr_whitening_0, '0']
- [lora_rx_0, out, blocks_message_debug_0, print]
- [lora_rx_0, out, epy_block_0_0, payload]
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', soapy_limesdr_sink_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [soapy_limesdr_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
