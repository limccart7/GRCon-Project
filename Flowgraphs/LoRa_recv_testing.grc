options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: LoRa_recv_testing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable_config
  parameters:
    config_file: /home/ubuntu/LoRa_Tests/LoRa_config.ini
    option: bw
    section: LoRa
    type: int
    value: '62500'
    writeback: None
  states: {}
- name: file_path
  id: variable_config
  parameters:
    config_file: /home/ubuntu/LoRa_Tests/LoRa_config.ini
    option: file_path
    section: LoRa
    type: string
    value: '0'
    writeback: None
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sf
  id: variable_config
  parameters:
    config_file: /home/ubuntu/LoRa_Tests/LoRa_config.ini
    option: sf
    section: LoRa
    type: int
    value: '7'
    writeback: None
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "import os\nfrom gnuradio import gr\nimport pmt\n\nclass payload_writer(gr.sync_block):\n    def __init__(self, filepath=\"/home/ubuntu/LoRa_Tests/message_storage.txt\"):\n        gr.sync_block.__init__(\n            self,\n            name=\"payload_writer\",\n            in_sig=None,\n            out_sig=None,\n        )\n        self.message_port_register_in(pmt.intern(\"payload\"))\n        self.set_msg_handler(pmt.intern(\"payload\"), self.handle_msg)\n        self.filepath = filepath\n        \n        # Check if the file exists\n        if not os.path.exists(self.filepath):\n            # Create the file if it does not exist\n            with open(self.filepath, 'w') as file:\n                pass\n        else:\n            # Overwrite the file every time the flowgraph is run if it exists\n            with open(self.filepath, 'w') as file:\n                file.write(\"\")\n\n    def handle_msg(self, msg):\n        if pmt.is_pair(msg):\n            payload = pmt.symbol_to_string(pmt.cdr(msg))\n        else:\n            payload = pmt.symbol_to_string(msg)\n        \n        with open(self.filepath, 'a') as file:\n            file.write(payload + \"\\n\")\n\n    def work(self, input_items, output_items):\n        return len(output_items)\n\n\n"
    filepath: '"/home/ubuntu/LoRa_Tests/message_storage.txt"'
  states: {state: disabled}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: sf
    soft_decoding: 'True'
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [lora_rx_0, out, blocks_message_debug_0, print]
- [lora_rx_0, out, epy_block_0_0, payload]
- [soapy_limesdr_source_0, '0', lora_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
