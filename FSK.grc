options:
  parameters:
    author: Ben Duval
    generate_options: qt_gui
    id: fsk2
    output_language: python
    title: 'FSK '
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: 5*fdev
  states: {}
- name: fdev
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5*symb_rate
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: baud_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    def __init__(self, samp_rate=1e6, fsk_deviation=500e3):\n        gr.sync_block.__init__(\n            self,\n            name='FSK Modulation',\n            in_sig=[np.uint8],\n            out_sig=[np.complex64]\n        )\n        self.samp_rate = samp_rate\n        self.fsk_deviation = fsk_deviation\n        self.center_freq = 0\n        self.phase_inc0 = 2.0 * np.pi * (self.center_freq - self.fsk_deviation) / self.samp_rate\n        self.phase_inc1 = 2.0 * np.pi * (self.center_freq + self.fsk_deviation) / self.samp_rate\n        self.phase = 0\n\n        # Register message port to receive chunk_ready messages\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_message)\n\n        self.chunk_data = None  # Store chunk data when received\n\n    def handle_message(self, msg):\n        # Handle the \"chunk_ready\" message\n        if pmt.is_pair(msg):\n            key = pmt.car(msg)\n            if pmt.eq(key, pmt.intern(\"chunk_ready\")):\n                self.chunk_data = pmt.to_python(pmt.cdr(msg))\n                #print(f\"Received chunk: {self.chunk_data[:10]}\")  # Debug: print the first 10 bits of the chunk\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        in0 = input_items[0]\n\n        # Process the input data\n        if len(in0) > 0:  # Ensure there's input data to process\n            #print(f\"Modulating data: {in0[:10]}\")  # Debug: print the first 10 bits of input data\n            for i in range(len(in0)):\n                if in0[i] == 0:\n                    self.phase += self.phase_inc0\n                else:\n                    self.phase += self.phase_inc1\n                out[i] = np.exp(1j * self.phase)\n                if self.phase > 2.0 * np.pi:\n                    self.phase -= 2.0 * np.pi\n        else:\n            print(\"Received empty input data\")  # Debug: indicate when input data is empty\n\n        return len(out)\n\n"
    fsk_deviation: fdev
    samp_rate: samp_rate
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class ber_block(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="ber_block",
                  in_sig=None,
                  out_sig=None)
              
              # Register input message ports
              self.message_port_register_in(pmt.intern("input_1"))
              self.message_port_register_in(pmt.intern("input_2"))
              
              # Register output message port
              self.message_port_register_out(pmt.intern("ber_output"))
              
              # Set message handlers
              self.set_msg_handler(pmt.intern("input_1"), self.handle_msg_1)
              self.set_msg_handler(pmt.intern("input_2"), self.handle_msg_2)
              
              # Initialize message variables
              self.msg_1 = None
              self.msg_2 = None

          def handle_msg_1(self, msg_pmt):
              # Convert PMT message to a list of unsigned 8-bit integers
              self.msg_1 = pmt.u8vector_elements(msg_pmt)
              self.calculate_ber()

          def handle_msg_2(self, msg_pmt):
              # Convert PMT message to a list of unsigned 8-bit integers
              self.msg_2 = pmt.u8vector_elements(msg_pmt)
              self.calculate_ber()

          def calculate_ber(self):
              # Ensure both messages are received and are the same length
              if self.msg_1 is not None and self.msg_2 is not None:
                  if len(self.msg_1) != len(self.msg_2):
                      print("Error: Input vectors are of different lengths")
                      return
                  
                  # Convert lists to NumPy arrays with dtype=uint8
                  data_1 = np.array(self.msg_1, dtype=np.uint8)
                  data_2 = np.array(self.msg_2, dtype=np.uint8)

                  # Calculate the bitwise XOR and count bit errors
                  bit_errors = np.sum(np.unpackbits(np.bitwise_xor(data_1, data_2)))
                  total_bits = len(data_1) * 8
                  ber = bit_errors / total_bits
                  
                  # Output BER as PMT message
                  ber_msg = pmt.to_pmt(ber)
                  self.message_port_pub(pmt.intern("ber_output"), ber_msg)

                  # Clear messages after calculation
                  self.msg_1 = None
                  self.msg_2 = None
  states: {}
- name: epy_block_12_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class bits_to_message(gr.sync_block):
          def __init__(self, preamble=[0xAB, 0xCD, 0xEF], header_length=1):
              gr.sync_block.__init__(
                  self,
                  name='Bits to Message',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.preamble = np.unpackbits(np.array(preamble, dtype=np.uint8))
              self.header_length = header_length
              self.buffer = np.array([], dtype=np.uint8)
              self.message_port_register_out(pmt.intern("crc_status"))  
              self.message_port_register_out(pmt.intern("extracted_payload"))  
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_message)
              self.current_chunk_index = 0  # Start expecting chunk 0
              self.process_flag = False  # Flag to control processing
              self.file_complete = False  # Flag to indicate if file transmission is complete
              self.final_chunk_processed = False  # Flag to indicate if the final chunk was successfully processed
              self.start_message_sent = False  # Flag to ensure start message is only sent once

          def start(self):
              """This method is called when the flowgraph starts."""
              if not self.start_message_sent:
                  start_msg = pmt.cons(pmt.from_long(0), pmt.intern("crc_start"))
                  self.message_port_pub(pmt.intern("crc_status"), start_msg)
                  self.start_message_sent = True
                  print("Start message sent to custom_message_to_bits block.")
              return super().start()

          def handle_message(self, msg):
              if pmt.is_pair(msg):
                  key = pmt.car(msg)
                  if pmt.eq(key, pmt.intern("demodulated_packet_ready")):
                      self.process_flag = True
                      demodulated_bits = pmt.to_python(pmt.cdr(msg))
                      self.buffer = np.concatenate((self.buffer, demodulated_bits))
                  elif pmt.eq(key, pmt.intern("file_complete")):
                      self.file_complete = True

          def detect_preamble(self, data):
              preamble_length = len(self.preamble)
              for i in range(len(data) - preamble_length + 1):
                  if np.array_equal(data[i:i + preamble_length], self.preamble):
                      return i + preamble_length
              return -1

          def compute_crc(self, data):
              crc = 0
              for byte in data:
                  crc ^= byte
                  for _ in range(8):
                      if crc & 0x80:
                          crc = (crc << 1) ^ 0x07  # Generator polynomial
                      else:
                          crc <<= 1
                  crc &= 0xFF
              return np.array([crc], dtype=np.uint8)

          def check_crc(self, message, received_crc):
              calculated_crc = self.compute_crc(message)
              return np.array_equal(calculated_crc, received_crc)

          def extract_chunk_index(self, buffer, start_index):
              """Extracts the 4-byte chunk index from the buffer."""
              chunk_index_bits = buffer[start_index:start_index + 32]  # 4 bytes = 32 bits
              chunk_index_bytes = np.packbits(chunk_index_bits)
              chunk_index = int.from_bytes(chunk_index_bytes, byteorder='big')  # Convert bytes to integer
              return chunk_index

          def work(self, input_items, output_items):
              if not self.process_flag or self.final_chunk_processed:
                  return 0  

              output_idx = 0  # Initialize output index

              while True:
                  preamble_index = self.detect_preamble(self.buffer)
                  if preamble_index == -1:
                      break

                  header_end = preamble_index + self.header_length * 8
                  if header_end > len(self.buffer):
                      break

                  header = self.buffer[preamble_index:header_end]
                  message_length = np.packbits(header)[0]
                  chunk_index_start = header_end
                  chunk_index_end = chunk_index_start + 32  # 4 bytes (32 bits)
                  
                  if chunk_index_end > len(self.buffer):
                      break

                  chunk_index = self.extract_chunk_index(self.buffer, chunk_index_start)

                  message_start = chunk_index_end
                  message_end = message_start + message_length * 8
                  crc_start = message_end
                  crc_end = crc_start + 8

                  if crc_end > len(self.buffer):
                      break

                  # Verify that the received chunk index matches the expected chunk index
                  if chunk_index != self.current_chunk_index:
                      #print(f"Expected chunk {self.current_chunk_index}, but received chunk {chunk_index}. Skipping.")
                      # Since chunk index does not match, skip this chunk and advance the buffer
                      self.buffer = self.buffer[crc_end:]  # Move buffer forward past this chunk
                      continue

                  message_bits = self.buffer[message_start:message_end]
                  crc_bits = self.buffer[crc_start:crc_end]

                  message_bytes = np.packbits(message_bits)
                  received_crc = np.packbits(crc_bits)

                  if self.check_crc(message_bytes, received_crc):
                      print(f"CRC passed for chunk {chunk_index}")
                      output_msg = pmt.cons(pmt.intern("crc_pass"), pmt.from_long(chunk_index))
                      self.message_port_pub(pmt.intern("crc_status"), output_msg)  # Send the crc_pass message

                      output_items[0][output_idx:output_idx + len(message_bytes)] = message_bytes
                      output_idx += len(message_bytes)
                      self.process_flag = False

                      # Output the extracted payload 
                      payload_msg = pmt.init_u8vector(len(message_bytes), message_bytes)
                      self.message_port_pub(pmt.intern("extracted_payload"), payload_msg)

                      # Move to the next expected chunk
                      self.current_chunk_index += 1  # Increment to expect the next chunk

                  else:
                      print(f"CRC failed for chunk {chunk_index}")
                      output_msg = pmt.cons(pmt.intern("crc_fail"), pmt.from_long(chunk_index))
                      self.message_port_pub(pmt.intern("crc_status"), output_msg)  # Send the crc_fail message

                  # Advance the buffer
                  self.buffer = self.buffer[crc_end:]

                  # Check if this is the final chunk
                  if self.file_complete and len(self.buffer) == 0:
                      self.final_chunk_processed = True
                      print("Final chunk processed. Halting further CRC checks.")
                      return -1  # Signal to stop the flowgraph

              self.consume(0, len(input_items[0]))

              if self.file_complete and len(self.buffer) == 0:  
                  print("File transmission complete. Halting flowgraph.")
                  return -1  

              return output_idx
    header_length: '1'
    preamble: '[0xAB, 0xCD, 0xEF, 0xAA, 0xBD, 0x35, 0xBB, 0x55]'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass fsk_demod(gr.sync_block):\n    def __init__(self, samp_rate=1e6, fsk_deviation=500e3):\n        gr.sync_block.__init__(\n            self,\n            name='FSK Demodulation',\n            in_sig=[np.complex64],\n            out_sig=[np.int8]\n        )\n        self.samp_rate = samp_rate\n        self.fsk_deviation = fsk_deviation\n        self.counter = 0  # Initialize the counter\n\n        # Register a message output port\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        for i in range(1, len(in0)):\n            phase_diff = np.angle(in0[i] * np.conj(in0[i-1]))\n            out[i] = 1 if phase_diff > 0 else 0\n\n        # Send a \"demodulated_packet_ready\" message after processing\n        demodulated_bits = pmt.init_u8vector(len(out), out)\n        demodulated_packet_ready_msg = pmt.cons(pmt.intern(\"demodulated_packet_ready\"), demodulated_bits)\n        self.message_port_pub(pmt.intern(\"out\"), demodulated_packet_ready_msg)\n\n        return len(output_items[0])\n\n"
    fsk_deviation: fdev
    samp_rate: samp_rate
  states: {}
- name: epy_block_5_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class custom_message_to_bits(gr.basic_block):
          def __init__(self, preamble=[0xAB, 0xCD, 0xEF], file_path="msg.txt"):
              gr.basic_block.__init__(self,
                  name="custom_message_to_bits",
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.preamble = np.array(preamble, dtype=np.uint8)
              self.file_path = file_path
              self.chunk_size = 229
              self.chunks = []
              self.payload_buffer = []  # Buffer to store payloads for BER calculation
              self.current_chunk_index = 0
              self.ready_to_send = False  # Flag to control when to send the first chunk

              # Register message ports
              self.message_port_register_in(pmt.intern("crc_status"))
              self.set_msg_handler(pmt.intern("crc_status"), self.handle_crc_status)

              self.message_port_register_out(pmt.intern("output_msg"))  # Unified output message port
              self.message_port_register_out(pmt.intern("payload_buffer_out"))  # Port to output the payload buffer

              self.update_message()

              # Set output multiple to accommodate the maximum possible packet size
              self.set_output_multiple(8 * (len(self.preamble) + self.chunk_size + 1 + 1 + 4))  # Added 4 for chunk index

          def add_crc(self, chunk):
              """Add CRC to the given chunk."""
              crc = 0
              for byte in chunk:
                  crc ^= byte
                  for _ in range(8):
                      if crc & 0x80:
                          crc = (crc << 1) ^ 0x07  # Generator polynomial
                      else:
                          crc <<= 1
                  crc &= 0xFF
              crc_bytes = np.array([crc], dtype=np.uint8)
              return np.concatenate((chunk, crc_bytes))

          def send_payload(self, idx):
              """Send the current payload chunk from the buffer."""
              if idx < len(self.payload_buffer):  # Ensure the index is within bounds
                  payload = self.payload_buffer[idx]

                  # Send only the payload as a PMT vector
                  payload_msg = pmt.init_u8vector(len(payload), payload)
                  self.message_port_pub(pmt.intern("payload_buffer_out"), payload_msg)
              else:
                  print(f"Index {idx} out of range for payload buffer")

          def update_message(self):
              try:
                  with open(self.file_path, "r") as file:
                      message = file.read().strip()
                  message_bytes = np.frombuffer(message.encode('utf-8'), dtype=np.uint8)
                  self.chunks = [self.add_crc(message_bytes[i:i + self.chunk_size]) for i in range(0, len(message_bytes), self.chunk_size)]
              except FileNotFoundError:
                  print("Message file not found. Using default message.")
                  default_message = "Default Message"
                  message_bytes = np.frombuffer(default_message.encode('utf-8'), dtype=np.uint8)
                  self.chunks = [self.add_crc(message_bytes)]

              # Populate the payload buffer
              self.payload_buffer = [chunk[:-1] for chunk in self.chunks]  # Store all payloads without CRC

          def general_work(self, input_items, output_items):
              output = output_items[0]
              
              if not self.ready_to_send:
                  return 0


              if self.ready_to_send and self.current_chunk_index < len(self.chunks):
                  chunk = self.chunks[self.current_chunk_index]
                  chunk_index = np.array([(self.current_chunk_index >> i) & 0xFF for i in (24, 16, 8, 0)], dtype=np.uint8)  # 4-byte chunk index
                  payload_length = len(chunk) - 1  # Exclude CRC byte
                  header = np.array([payload_length], dtype=np.uint8)
                  packet = np.concatenate((self.preamble, header, chunk_index, chunk))
                  packet_bits = self.byte_to_bits(packet)

                  # Ensure the output buffer is large enough
                  if len(packet_bits) > len(output):
                      print(f"Output buffer too small. Needed: {len(packet_bits)}, available: {len(output)}")
                      return 0

                  # Write packet_bits to the output buffer
                  output[:len(packet_bits)] = packet_bits
                  produced = len(packet_bits)

                  # Mark as produced
                  self.consume_each(0)  # No input to consume
                  return produced
              else:
                  print("File transmission complete.")
                  output_msg = pmt.cons(pmt.intern("file_complete"), pmt.to_pmt(self.file_path))  # File completion message with file path
                  self.message_port_pub(pmt.intern("output_msg"), output_msg)
                  return -1  # Signal to GNU Radio to stop the flowgraph

          def byte_to_bits(self, byte_array):
              """Converts a byte array to a bit array."""
              return np.unpackbits(byte_array.astype(np.uint8))  # Ensure the array is uint8

          def handle_crc_status(self, msg):
              car_part = pmt.car(msg)  # Get the car part of the message

              # Check if the car part is a symbol
              if pmt.is_symbol(car_part):
                  status = pmt.symbol_to_string(car_part)
              else:
                  # If not a symbol, just convert it to a string for logging (if needed)
                  status = str(pmt.to_python(car_part))

              # Handle the message based on the car part
              if pmt.is_symbol(pmt.cdr(msg)):
                  message = pmt.symbol_to_string(pmt.cdr(msg))
                  if message == "crc_start":
                      print("Received start message. Ready to send the first chunk.")
                      self.ready_to_send = True  # Set flag to start sending chunks
                      self.current_chunk_index = 0  # Start from the first chunk
                      # Trigger the sending of the first chunk immediately
                      chunk_data = pmt.init_u8vector(len(self.chunks[self.current_chunk_index]), self.chunks[self.current_chunk_index])
                      output_msg = pmt.cons(pmt.intern("chunk_ready"), chunk_data)
                      self.message_port_pub(pmt.intern("output_msg"), output_msg)
                      self.send_payload(self.current_chunk_index)

              elif status == "crc_pass":
                  if self.current_chunk_index < len(self.chunks)-1:
                      print(f"CRC passed for chunk {self.current_chunk_index}. Moving to the next chunk.")
                      time.sleep(1)
                      self.current_chunk_index += 1
                      # Send the next chunk
                      chunk_data = pmt.init_u8vector(len(self.chunks[self.current_chunk_index]), self.chunks[self.current_chunk_index])
                      output_msg = pmt.cons(pmt.intern("chunk_ready"), chunk_data)
                      self.message_port_pub(pmt.intern("output_msg"), output_msg)

                      # Send the corresponding payload
                      self.send_payload(self.current_chunk_index)
                  else:
                      print("All chunks have been sent.")
                      output_msg = pmt.cons(pmt.intern("file_complete"), pmt.to_pmt(self.file_path))  # File completion message with file path
                      self.message_port_pub(pmt.intern("output_msg"), output_msg)
                      return -1  # Signal to GNU Radio to stop the flowgraph
              elif status == "crc_fail":
                  print(f"Resending chunk {self.current_chunk_index} due to CRC failure.")
    file_path: '"/home/ben/Documents/test2"'
    preamble: '[0xAB, 0xCD, 0xEF, 0xAA, 0xBD, 0x35, 0xBB, 0x55]'
  states: {}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport os\n\nclass pmt_to_file_sink(gr.basic_block):\n    def __init__(self, filename='rx'):\n        gr.basic_block.__init__(self,\n            name=\"PMT File Sink\",\n            in_sig=[],\n            out_sig=[])\n        \n        # Register the input message port\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n        \n        # Open the file for writing\n        self.filename = filename\n        self.file = open(self.filename, \"w\")\n\n    def handle_msg(self, msg):\n        # Check if the message is a u8vector\n        if pmt.is_u8vector(msg):\n            # Convert u8vector to a Python list\n            msg_list = pmt.u8vector_elements(msg)\n            # Convert list to a byte string\n            msg_str = ''.join([chr(x) for x in msg_list])\n            # Write the byte string to file\n            self.file.write(msg_str)# + \"\\n\")\n        else:\n            # Handle unexpected PMT types (just to be safe)\n            self.file.write(\"Unexpected PMT type\\n\")\n\n        # Ensure the data is written to the file\n        self.file.flush()\n\n    def stop(self):\n        # Close the file when the block is stopped\n        self.file.close()\n        return super().stop()\n"
    filename: '''/home/ben/Documents/rx'''
  states: {}
- name: epy_block_7_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport os\n\nclass pmt_to_file_sink(gr.basic_block):\n    def __init__(self, filename='rx'):\n        gr.basic_block.__init__(self,\n            name=\"PMT File Sink\",\n            in_sig=[],\n            out_sig=[])\n        \n        # Register the input message port\n        self.message_port_register_in(pmt.intern(\"in\"))\n        self.set_msg_handler(pmt.intern(\"in\"), self.handle_msg)\n        \n        # Open the file for writing\n        self.filename = filename\n        self.file = open(self.filename, \"w\")\n\n    def handle_msg(self, msg):\n        # Check if the message is a u8vector\n        if pmt.is_u8vector(msg):\n            # Convert u8vector to a Python list\n            msg_list = pmt.u8vector_elements(msg)\n            # Convert list to a byte string\n            msg_str = ''.join([chr(x) for x in msg_list])\n            # Write the byte string to file\n            self.file.write(msg_str)# + \"\\n\")\n        else:\n            # Handle unexpected PMT types (just to be safe)\n            self.file.write(\"Unexpected PMT type\\n\")\n\n        # Ensure the data is written to the file\n        self.file.flush()\n\n    def stop(self):\n        # Close the file when the block is stopped\n        self.file.close()\n        return super().stop()\n"
    filename: '''/home/ben/Documents/payload_sent'''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '10'
    gain: '1'
    interp: '10'
    ntaps: '1000'
    samp_rate: samp_rate
    sym_rate: symb_rate
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '10'
    gain: '10'
    ntaps: '1000'
    samp_rate: samp_rate
    sym_rate: symb_rate
    type: fir_filter_ccf
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_limesdr_sink_1
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_limesdr_source_1
  id: soapy_limesdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://127.0.0.1:55450"'
    timeout: '0'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: '"tcp://127.0.0.1:55450"'
    timeout: '0'
  states: {}

connections:
- [epy_block_0, '0', root_raised_cosine_filter_0, '0']
- [epy_block_1, ber_output, blocks_message_debug_0, print]
- [epy_block_12_0_0, '0', blocks_null_sink_0, '0']
- [epy_block_12_0_0, crc_status, zeromq_push_msg_sink_0, in]
- [epy_block_12_0_0, extracted_payload, epy_block_7, in]
- [epy_block_2, '0', epy_block_12_0_0, '0']
- [epy_block_2, out, epy_block_12_0_0, in]
- [epy_block_5_0, '0', epy_block_0, '0']
- [epy_block_5_0, output_msg, epy_block_0, in]
- [epy_block_5_0, payload_buffer_out, epy_block_7_0, in]
- [root_raised_cosine_filter_0, '0', soapy_limesdr_sink_1, '0']
- [root_raised_cosine_filter_0_0, '0', epy_block_2, '0']
- [soapy_limesdr_source_1, '0', root_raised_cosine_filter_0_0, '0']
- [zeromq_pull_msg_source_0, out, epy_block_5_0, crc_status]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
